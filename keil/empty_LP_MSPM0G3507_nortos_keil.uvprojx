# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "C:/ti/mspm0_sdk_2_01_00_03/tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: C:\ti\mspm0_sdk_2_01_00_03\source\third_party\CMSIS\Core\Include;C:\ti\mspm0_sdk_2_01_00_03\source;C:\ti\mspm0_sdk_2_01_00_03\source\ti\driverlib;..\..\Car_Control_Try1;..\keil;..\BSP;..\ti;..\BSP\eMPL;..\..\Car_Control_Summary;..\..\Car_Control_Summary_1-2Completed
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: C:\ti\mspm0_sdk_2_01_00_03\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c board.h
    ./: startup_mspm0g350x_uvision.s
  group Motor_Drive
    ./: motor.c motor.h
  group MPU6050
    ../BSP/: bsp_mpu6050.c bsp_mpu6050.h
    ../BSP/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
    ../ti/: dl_vref.c dl_uart.c dl_trng.c dl_timer.c dl_spi.c dl_rtc_common.c dl_opa.c dl_mcan.c dl_mathacl.c dl_lfss.c dl_lcd.c dl_keystorectl.c dl_i2c.c dl_flashctl.c dl_dma.c dl_dac12.c dl_crcp.c dl_crc.c dl_common.c dl_aesadv.c dl_aes.c dl_adc12.c driverlib.h dl_wwdt.h dl_vref.h dl_uart_main.h dl_uart_extend.h dl_uart.h dl_trng.h dl_timerg.h dl_timera.h dl_timer.h dl_tamperio.h dl_spi.h dl_scratchpad.h dl_rtc_common.h dl_rtc_a.h dl_rtc.h dl_opa.h dl_mcan.h dl_mathacl.h dl_lfss.h dl_lcd.h dl_keystorectl.h dl_iwdt.h dl_i2c.h dl_gpio.h dl_gpamp.h dl_flashctl.h dl_dma.h dl_dac12.h dl_crcp.h dl_crc.h dl_comp.h dl_common.h dl_aesadv.h dl_aes.h dl_adc12.h
